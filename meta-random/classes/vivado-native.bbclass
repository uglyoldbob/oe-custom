vivado_prepare_run() {
	export PATH=$PATH:${WORKDIR}/recipe-sysroot-native${prefix}/vivado/Vivado/2024.2/bin
}

