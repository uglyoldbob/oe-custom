SWU_TO_DEPLOY = "auto-radio-swu-qemux86-64.rootfs.swu"
INSTALL_DRIVE = "/dev/sda"
require installer.inc
