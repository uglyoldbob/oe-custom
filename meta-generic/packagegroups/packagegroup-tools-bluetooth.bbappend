RDEPENDS:${PN}:remove = " bluez5-obex "