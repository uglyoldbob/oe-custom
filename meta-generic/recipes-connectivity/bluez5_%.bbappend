PACKAGECONFIG:remove = "obex-profiles"