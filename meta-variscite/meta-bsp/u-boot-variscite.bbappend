FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot:"

#SRC_URI:append = " file://0001-Add-multi-env-support.patch"