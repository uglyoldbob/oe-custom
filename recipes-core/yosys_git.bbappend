SRC_URI = "git://github.com/YosysHQ/yosys;protocol=https;branch=main"
SRCREV = "1bf908dea8e09f29e10b7eb44501151a63c68eb3"
PV = "0.45+git${SRCPV}"
